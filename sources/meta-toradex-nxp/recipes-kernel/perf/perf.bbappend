# perf with a 4.4 kernel no longer compiles
COMPATIBLE_MACHINE:use-nxp-bsp:colibri-vf = "(^$)"
